# Keil uVision project Project.uvprojx, settings and files
target STWIN-Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L4R9ZITx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IROM(0x08000000-0x81FFFFF) IROM2(0x0-0xFFFFFFFFFFFFFFFF) IROM(0x0-0xFFFFFFFFFFFFFFFF) IROM2(0x0-0xFFFFFFFFFFFFFFFF) IROM3(0x0-0xFFFFFFFFFFFFFFFF) IRAM(0x20000000-0x2002FFFF) IRAM2(0x20030000-0x2003FFFF) IRAM(0x0-0xFFFFFFFFFFFFFFFF) IRAM2(0x0-0xFFFFFFFFFFFFFFFF) IRAM3(0x0-0xFFFFFFFFFFFFFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STWIN-Project.axf +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=.\STWIN-Project\Objects\@L.bin !L
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: STM32L4R9xx,USE_HAL_DRIVER,USE_USB_FS,ARM_MATH_CM4,USE_STWIN,USE_BLE_OUTPUT
  c include: ..\..\Inc;..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\CMSIS\DSP\Include;..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\Drivers\BSP\Components\Common;..\..\..\Drivers\BSP\Components\hts221;..\..\..\Drivers\BSP\Components\lps22hh;..\..\..\Drivers\BSP\Components\iis2mdc;..\..\..\Drivers\BSP\Components\ism330dhcx;..\..\..\Drivers\BSP\STWIN;..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\..\Middlewares\ST\STM32_MotionAC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionAW_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionEC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionFX_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionGC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionID_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionMC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionPM_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionPW_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionTL_Library\Inc;..\..\..\Middlewares\Third_Party\FatFs\src\drivers;..\..\..\Middlewares\Third_Party\FatFs\src;..\..\..\Middlewares\ST\BlueNRG2\includes;..\..\..\Middlewares\ST\BlueNRG2\utils;..\..\..\Middlewares\ST\BlueNRG2\hci\hci_tl_patterns\Basic;..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC_MSC\Inc;..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x48000000 size 0x900ae806
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x20030000 size 0x10000
  group Drivers/BSP/Components
    ../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../../Drivers/BSP/Components/iis2mdc/: iis2mdc.c iis2mdc_reg.c
    ../../../Drivers/BSP/Components/lps22hh/: lps22hh.c lps22hh_reg.c
    ../../../Drivers/BSP/Components/ism330dhcx/: ism330dhcx.c ism330dhcx_reg.c
  group Drivers/BSP/STWIN
    ../../../Drivers/BSP/STWIN/: STWIN.c STWIN_bus.c STWIN_env_sensors.c STWIN_motion_sensors.c STWIN_env_sensors_ex.c STWIN_motion_sensors_ex.c STWIN_sd.c
  group Drivers/CMSIS
    ../../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_ll_sdmmc.c stm32l4xx_ll_usb.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_rtc_ex.c
  group Application/MDK-ARM
    ./: startup_stm32l4r9xx.s
  group Application/AlgoBuilder
    ../../Src/: ab_buffers.c ab_display.c ab_fft.c ab_sensor_hub.c ab_sequential_logic.c ab_signal.c ab_user_input.c ab_ble.c
  group Application/User
    ../../Src/: algo_builder.c demo_serial.c cube_hal_l4.c main.c sd_diskio_STWIN.c sensor_commands.c serial_protocol.c stm32l4xx_hal_msp.c stm32l4xx_it.c usbd_cdc_interface.c usbd_conf.c usbd_desc.c vcom.c hci_tl_interface.c sensor_service.c fatfs.c usbd_storage_if.c
  group Middlewares/STM32_MotionAC_Library
    ../../../Middlewares/ST/STM32_MotionAC_Library/Lib/: MotionAC_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionAW_Library
    ../../../Middlewares/ST/STM32_MotionAW_Library/Lib/: MotionAW_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionEC_Library
    ../../../Middlewares/ST/STM32_MotionEC_Library/Lib/: MotionEC_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionFX_Library
    ../../../Middlewares/ST/STM32_MotionFX_Library/Lib/: MotionFX_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionGC_Library
    ../../../Middlewares/ST/STM32_MotionGC_Library/Lib/: MotionGC_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionID_Library
    ../../../Middlewares/ST/STM32_MotionID_Library/Lib/: MotionID_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionMC_Library
    ../../../Middlewares/ST/STM32_MotionMC_Library/Lib/: MotionMC_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionPM_Library
    ../../../Middlewares/ST/STM32_MotionPM_Library/Lib/: MotionPM_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionPW_Library
    ../../../Middlewares/ST/STM32_MotionPW_Library/Lib/: MotionPW_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionTL_Library
    ../../../Middlewares/ST/STM32_MotionTL_Library/Lib/: MotionTL_CM4F_wc16_ot.a
  group Middlewares/STM32_USBD_Library/Class/CDC
    ../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/CMSIS_DSP_Lib
    ../../../Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group Middlewares/FatFs/Core
    ../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Options
    ../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/BlueNRG2/Controller
    ../../../Middlewares/ST/BlueNRG2/hci/controller/: bluenrg1_gap_aci.c bluenrg1_gatt_aci.c bluenrg1_hal_aci.c bluenrg1_l2cap_aci.c
  group Middlewares/BlueNRG2/HCI_TL
    ../../../Middlewares/ST/BlueNRG2/hci/: bluenrg1_events.c bluenrg1_events_cb.c bluenrg1_hci_le.c
    ../../../Middlewares/ST/BlueNRG2/hci/hci_tl_patterns/Basic/: hci_tl.c
  group Middlewares/BlueNRG2/utils
    ../../../Middlewares/ST/BlueNRG2/utils/: ble_list.c
  group Middlewares/STM32_USBD_Library/Class/CDC_MSC
    ../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC_MSC/Src/: usbd_cdc_msc.c
  group Middlewares/STM32_USBD_Library/Class/MSC
    ../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
software components: CMSIS:CORE 5.6.0
