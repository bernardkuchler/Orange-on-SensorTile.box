# Keil uVision project Project_ab.uvprojx, settings and files
target SensorTile.box-Project (6180000::V6.18::ARMCLANG)
  device: STM32L4R9ZIJx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) XRAM(0x20040000,0x00060000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: SensorTile.box-Project.axf +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=.\SensorTile.box-Project\Objects\@L.bin !L
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: STM32L4R9xx,USE_HAL_DRIVER,USE_USB_FS,ARM_MATH_CM4,USE_SENSORTILEBOX,USE_BLE_OUTPUT
  c include: ..\..\Inc;..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\CMSIS\DSP\Include;..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\Drivers\BSP\Components\Common;..\..\..\Drivers\BSP\Components\hts221;..\..\..\Drivers\BSP\Components\lps22hh;..\..\..\Drivers\BSP\Components\lis2mdl;..\..\..\Drivers\BSP\Components\lsm6dsox;..\..\..\Drivers\BSP\SensorTile.box;..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\..\Middlewares\ST\STM32_MotionAC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionAW_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionEC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionFX_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionGC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionID_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionMC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionPM_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionPW_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionTL_Library\Inc;..\..\..\Middlewares\Third_Party\FatFs\src\drivers;..\..\..\Middlewares\Third_Party\FatFs\src;..\..\..\Middlewares\ST\BlueNRG2\includes;..\..\..\Middlewares\ST\BlueNRG2\utils;..\..\..\Middlewares\ST\BlueNRG2\hci\hci_tl_patterns\Basic;..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC_MSC\Inc;..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT6: RAM 0x20040000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/Components
    ./SensorTile.box-Project/Objects/: hts221.o hts221_reg.o lis2mdl.o lis2mdl_reg.o lps22hh.o lps22hh_reg.o lsm6dsox.o lsm6dsox_reg.o
  group Drivers/BSP/SensorTile.box
    ./SensorTile.box-Project/Objects/: sensortile.box.o sensortile.box_bus.o sensortile.box_env_sensors.o sensortile.box_env_sensors_ex.o sensortile.box_motion_sensors.o sensortile.box_motion_sensors_ex.o sensortile.box_sd.o
  group Drivers/CMSIS
    ./SensorTile.box-Project/Objects/: system_stm32l4xx.o
  group Drivers/STM32L4xx_HAL_Driver
    ./SensorTile.box-Project/Objects/: stm32l4xx_hal.o stm32l4xx_hal_adc.o stm32l4xx_hal_adc_ex.o stm32l4xx_hal_cortex.o stm32l4xx_hal_dma.o stm32l4xx_hal_gpio.o stm32l4xx_hal_i2c.o stm32l4xx_hal_i2c_ex.o stm32l4xx_hal_pcd.o stm32l4xx_hal_pcd_ex.o stm32l4xx_hal_pwr.o stm32l4xx_hal_pwr_ex.o stm32l4xx_hal_rcc.o stm32l4xx_hal_rcc_ex.o stm32l4xx_hal_rtc.o stm32l4xx_hal_rtc_ex.o stm32l4xx_hal_sd.o stm32l4xx_hal_sd_ex.o stm32l4xx_hal_spi.o stm32l4xx_hal_tim.o stm32l4xx_hal_tim_ex.o stm32l4xx_ll_sdmmc.o stm32l4xx_ll_usb.o
  group Example/MDK-ARM
    ./SensorTile.box-Project/Objects/: startup_stm32l4r9xx.o
  group Example/AlgoBuilder
    ./SensorTile.box-Project/Objects/: ab_buffers.o ab_display.o ab_fft.o ab_sensor_hub.o ab_sequential_logic.o ab_signal.o ab_user_input.o ab_ble.o
  group Example/User
    ../../Src/: algo_builder.c
    ./SensorTile.box-Project/Objects/: cube_hal_l4.o demo_serial.o main.o sensor_commands.o serial_protocol.o stm32l4xx_hal_msp.o stm32l4xx_it.o usbd_cdc_interface.o usbd_conf.o usbd_desc.o vcom.o sd_diskio_sensortile.box.o hci_tl_interface.o sensor_service.o fatfs.o usbd_storage_if.o
  group Middlewares/STM32_MotionAC_Library
    ../../../Middlewares/ST/STM32_MotionAC_Library/Lib/: MotionAC_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionAW_Library
    ../../../Middlewares/ST/STM32_MotionAW_Library/Lib/: MotionAW_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionEC_Library
    ../../../Middlewares/ST/STM32_MotionEC_Library/Lib/: MotionEC_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionFX_Library
    ../../../Middlewares/ST/STM32_MotionFX_Library/Lib/: MotionFX_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionGC_Library
    ../../../Middlewares/ST/STM32_MotionGC_Library/Lib/: MotionGC_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionID_Library
    ../../../Middlewares/ST/STM32_MotionID_Library/Lib/: MotionID_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionMC_Library
    ../../../Middlewares/ST/STM32_MotionMC_Library/Lib/: MotionMC_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionPM_Library
    ../../../Middlewares/ST/STM32_MotionPM_Library/Lib/: MotionPM_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionPW_Library
    ../../../Middlewares/ST/STM32_MotionPW_Library/Lib/: MotionPW_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionTL_Library
    ../../../Middlewares/ST/STM32_MotionTL_Library/Lib/: MotionTL_CM4F_wc16_ot.a
  group Middlewares/STM32_USBD_Library/Core
    ./SensorTile.box-Project/Objects/: usbd_core.o usbd_ctlreq.o usbd_ioreq.o
  group Middlewares/STM32_USBD_Library/Class/CDC
    ./SensorTile.box-Project/Objects/: usbd_cdc.o
  group Middlewares/CMSIS_DSP_Lib
    ../../../Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group Middlewares/FatFs/Core
    ./SensorTile.box-Project/Objects/: diskio.o ff.o ff_gen_drv.o
  group Middlewares/FatFs/Options
    ./SensorTile.box-Project/Objects/: syscall.o unicode.o
  group Middlewares/BlueNRG2/Controller
    ./SensorTile.box-Project/Objects/: bluenrg1_gap_aci.o bluenrg1_gatt_aci.o bluenrg1_hal_aci.o bluenrg1_l2cap_aci.o
  group Middlewares/BlueNRG2/HCI_TL
    ./SensorTile.box-Project/Objects/: bluenrg1_events.o bluenrg1_events_cb.o bluenrg1_hci_le.o hci_tl.o
  group Middlewares/BlueNRG2/utils
    ./SensorTile.box-Project/Objects/: ble_list.o
  group Middlewares/STM32_USBD_Library/Class/CDC_MSC
    ./SensorTile.box-Project/Objects/: usbd_cdc_msc.o
  group Middlewares/STM32_USBD_Library/Class/MSC
    ./SensorTile.box-Project/Objects/: usbd_msc.o usbd_msc_bot.o usbd_msc_data.o usbd_msc_scsi.o
