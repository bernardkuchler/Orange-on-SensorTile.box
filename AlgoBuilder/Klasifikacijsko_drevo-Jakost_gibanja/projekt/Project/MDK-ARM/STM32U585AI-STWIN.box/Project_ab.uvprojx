# Keil uVision project Project_ab.uvprojx, settings and files
target STWIN.box-Project (6180000::V6.18::ARMCLANG)
  device: STM32U585AIIx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x20040000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: STWIN.box-Project.axf +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=.\STWIN.box-Project\Objects\@L.bin !L
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: STM32U585xx,USE_HAL_DRIVER,USE_USB_FS,ARM_MATH_ARMV8MML,USE_STWINBOX
  c include: ..\..\Inc;..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\CMSIS\DSP\Include;..\..\..\Drivers\CMSIS\Device\ST\STM32U5xx\Include;..\..\..\Drivers\BSP\Components\Common;..\..\..\Drivers\BSP\Components\stts22h;..\..\..\Drivers\BSP\Components\ilps22qs;..\..\..\Drivers\BSP\Components\iis2mdc;..\..\..\Drivers\BSP\Components\ism330dhcx;..\..\..\Drivers\BSP\STWIN.box;..\..\..\Drivers\STM32U5xx_HAL_Driver\Inc;..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\..\Middlewares\ST\STM32_MotionAC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionAW_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionEC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionFX_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionGC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionID_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionMC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionPM_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionPW_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionTL_Library\Inc;..\..\..\Middlewares\Third_Party\FatFs\src\drivers;..\..\..\Middlewares\Third_Party\FatFs\src;..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC_MSC\Inc;..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x20040000 size 0x80000
  group STWIN.box/Drivers/BSP/Components
    ./STWIN.box-Project/Objects/: iis2mdc.o iis2mdc_reg.o ilps22qs.o ilps22qs_reg.o ism330dhcx.o ism330dhcx_reg.o ism330is.o ism330is_reg.o stts22h.o stts22h_reg.o
  group ISM330IS/Drivers/BSP/Components
    ./STWIN.box_ISM330IS-Project/Objects/: iis2mdc.o iis2mdc_reg.o ilps22qs.o ilps22qs_reg.o ism330dhcx.o ism330dhcx_reg.o ism330is.o ism330is_reg.o stts22h.o stts22h_reg.o
  group STWIN.box/Drivers/BSP/STWIN.box
    ./STWIN.box-Project/Objects/: stwin.box.o stwin.box_bc.o stwin.box_bus.o stwin.box_env_sensors.o stwin.box_env_sensors_ex.o stwin.box_motion_sensors.o stwin.box_motion_sensors_ex.o stwin.box_sd.o
  group ISM330IS/Drivers/BSP/STWIN.box
    ./STWIN.box_ISM330IS-Project/Objects/: stwin.box.o stwin.box_bc.o stwin.box_bus.o stwin.box_env_sensors.o stwin.box_env_sensors_ex.o stwin.box_motion_sensors.o stwin.box_motion_sensors_ex.o stwin.box_sd.o
  group STWIN.box/Drivers/CMSIS
    ./STWIN.box-Project/Objects/: system_stm32u5xx.o
  group ISM330IS/Drivers/CMSIS
    ./STWIN.box_ISM330IS-Project/Objects/: system_stm32u5xx.o
  group STWIN.box/Drivers/STM32U5xx_HAL_Driver
    ./STWIN.box-Project/Objects/: stm32u5xx_hal.o stm32u5xx_hal_adc.o stm32u5xx_hal_adc_ex.o stm32u5xx_hal_cortex.o stm32u5xx_hal_crc.o stm32u5xx_hal_crc_ex.o stm32u5xx_hal_dma.o stm32u5xx_hal_dma_ex.o stm32u5xx_hal_exti.o stm32u5xx_hal_gpio.o stm32u5xx_hal_i2c.o stm32u5xx_hal_i2c_ex.o stm32u5xx_hal_icache.o stm32u5xx_hal_mdf.o stm32u5xx_hal_mmc.o stm32u5xx_hal_mmc_ex.o stm32u5xx_hal_pcd.o stm32u5xx_hal_pcd_ex.o stm32u5xx_hal_pwr.o stm32u5xx_hal_pwr_ex.o stm32u5xx_hal_rcc.o stm32u5xx_hal_rcc_ex.o stm32u5xx_hal_rtc.o stm32u5xx_hal_rtc_ex.o stm32u5xx_hal_sd.o stm32u5xx_hal_sd_ex.o stm32u5xx_hal_spi.o stm32u5xx_hal_spi_ex.o stm32u5xx_hal_tim.o stm32u5xx_hal_tim_ex.o stm32u5xx_hal_uart.o stm32u5xx_hal_uart_ex.o stm32u5xx_ll_sdmmc.o stm32u5xx_ll_usb.o
  group ISM330IS/Drivers/STM32U5xx_HAL_Driver
    ./STWIN.box_ISM330IS-Project/Objects/: stm32u5xx_hal.o stm32u5xx_hal_adc.o stm32u5xx_hal_adc_ex.o stm32u5xx_hal_cortex.o stm32u5xx_hal_crc.o stm32u5xx_hal_crc_ex.o stm32u5xx_hal_dma.o stm32u5xx_hal_dma_ex.o stm32u5xx_hal_exti.o stm32u5xx_hal_gpio.o stm32u5xx_hal_i2c.o stm32u5xx_hal_i2c_ex.o stm32u5xx_hal_icache.o stm32u5xx_hal_mdf.o stm32u5xx_hal_mmc.o stm32u5xx_hal_mmc_ex.o stm32u5xx_hal_pcd.o stm32u5xx_hal_pcd_ex.o stm32u5xx_hal_pwr.o stm32u5xx_hal_pwr_ex.o stm32u5xx_hal_rcc.o stm32u5xx_hal_rcc_ex.o stm32u5xx_hal_rtc.o stm32u5xx_hal_rtc_ex.o stm32u5xx_hal_sd.o stm32u5xx_hal_sd_ex.o stm32u5xx_hal_spi.o stm32u5xx_hal_spi_ex.o stm32u5xx_hal_tim.o stm32u5xx_hal_tim_ex.o stm32u5xx_hal_uart.o stm32u5xx_hal_uart_ex.o stm32u5xx_ll_sdmmc.o stm32u5xx_ll_usb.o
  group Application/MDK-ARM
    ./: startup_stm32u585xx.s
  group STWIN.box/Application/AlgoBuilder
    ./STWIN.box-Project/Objects/: ab_buffers.o ab_display.o ab_fft.o ab_sensor_hub.o ab_sequential_logic.o ab_signal.o ab_user_input.o
  group ISM330IS/Application/AlgoBuilder
    ./STWIN.box_ISM330IS-Project/Objects/: ab_buffers.o ab_display.o ab_fft.o ab_sensor_hub.o ab_sequential_logic.o ab_signal.o ab_user_input.o
  group STWIN.box/Application/User
    ../../Src/: algo_builder.c
    ./STWIN.box-Project/Objects/: cube_hal_u5.o demo_serial.o fatfs.o main.o sd_diskio_stwin.box.o sensor_commands.o serial_protocol.o stm32u5xx_hal_msp.o stm32u5xx_it.o usbd_cdc_interface.o usbd_conf.o usbd_desc.o usbd_storage_if.o vcom.o
  group ISM330IS/Application/User
    ./STWIN.box_ISM330IS-Project/Objects/: algo_builder.o cube_hal_u5.o demo_serial.o fatfs.o main.o sd_diskio_stwin.box.o sensor_commands.o serial_protocol.o stm32u5xx_hal_msp.o stm32u5xx_it.o usbd_cdc_interface.o usbd_conf.o usbd_desc.o usbd_storage_if.o vcom.o
  group Middlewares/STM32_MotionAC_Library
    ../../../Middlewares/ST/STM32_MotionAC_Library/Lib/: MotionAC_CM33F_wc16_ot.a
  group Middlewares/STM32_MotionAW_Library
    ../../../Middlewares/ST/STM32_MotionAW_Library/Lib/: MotionAW_CM33F_wc16_ot.a
  group Middlewares/STM32_MotionEC_Library
    ../../../Middlewares/ST/STM32_MotionEC_Library/Lib/: MotionEC_CM33F_wc16_ot.a
  group Middlewares/STM32_MotionFX_Library
    ../../../Middlewares/ST/STM32_MotionFX_Library/Lib/: MotionFX_CM33F_wc16_ot.a
  group Middlewares/STM32_MotionGC_Library
    ../../../Middlewares/ST/STM32_MotionGC_Library/Lib/: MotionGC_CM33F_wc16_ot.a
  group Middlewares/STM32_MotionID_Library
    ../../../Middlewares/ST/STM32_MotionID_Library/Lib/: MotionID_CM33F_wc16_ot.a
  group Middlewares/STM32_MotionMC_Library
    ../../../Middlewares/ST/STM32_MotionMC_Library/Lib/: MotionMC_CM33F_wc16_ot.a
  group Middlewares/STM32_MotionPM_Library
    ../../../Middlewares/ST/STM32_MotionPM_Library/Lib/: MotionPM_CM33F_wc16_ot.a
  group Middlewares/STM32_MotionPW_Library
    ../../../Middlewares/ST/STM32_MotionPW_Library/Lib/: MotionPW_CM33F_wc16_ot.a
  group Middlewares/STM32_MotionTL_Library
    ../../../Middlewares/ST/STM32_MotionTL_Library/Lib/: MotionTL_CM33F_wc16_ot.a
  group STWIN.box/Middlewares/STM32_USBD_Library/Class/CDC
    ./STWIN.box-Project/Objects/: usbd_cdc.o
  group ISM330IS/Middlewares/STM32_USBD_Library/Class/CDC
    ./STWIN.box_ISM330IS-Project/Objects/: usbd_cdc.o
  group STWIN.box/Middlewares/STM32_USBD_Library/Core
    ./STWIN.box-Project/Objects/: usbd_core.o usbd_ctlreq.o usbd_ioreq.o
  group ISM330IS/Middlewares/STM32_USBD_Library/Core
    ./STWIN.box_ISM330IS-Project/Objects/: usbd_core.o usbd_ctlreq.o usbd_ioreq.o
  group Middlewares/CMSIS_DSP_Lib
    ../../../Drivers/CMSIS/Lib/ARM/: arm_ARMv8MMLlfsp_math.lib
  group STWIN.box/Middlewares/FatFs/Core
    ./STWIN.box-Project/Objects/: diskio.o ff.o ff_gen_drv.o
  group ISM330IS/Middlewares/FatFs/Core
    ./STWIN.box_ISM330IS-Project/Objects/: diskio.o ff.o ff_gen_drv.o
  group STWIN.box/Middlewares/FatFs/Options
    ./STWIN.box-Project/Objects/: syscall.o unicode.o
  group ISM330IS/Middlewares/FatFs/Options
    ./STWIN.box_ISM330IS-Project/Objects/: syscall.o unicode.o
  group STWIN.box/Middlewares/STM32_USBD_Library/Class/CDC_MSC
    ./STWIN.box-Project/Objects/: usbd_cdc_msc.o
  group ISM330IS/Middlewares/STM32_USBD_Library/Class/CDC_MSC
    ./STWIN.box_ISM330IS-Project/Objects/: usbd_cdc_msc.o
  group STWIN.box/Middlewares/STM32_USBD_Library/Class/MSC
    ./STWIN.box-Project/Objects/: usbd_msc.o usbd_msc_bot.o usbd_msc_data.o usbd_msc_scsi.o
  group ISM330IS/Middlewares/STM32_USBD_Library/Class/MSC
    ./STWIN.box_ISM330IS-Project/Objects/: usbd_msc.o usbd_msc_bot.o usbd_msc_data.o usbd_msc_scsi.o
target STWIN.box_ISM330IS-Project (6180000::V6.18::ARMCLANG)
  device: STM32U585AIIx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.0.0
  cpu: as above
  output: STWIN.box-Project.axf +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=.\STWIN.box_ISM330IS-Project\Objects\@L.bin !L
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: as above
  c include: ..\..\Inc;..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\CMSIS\DSP\Include;..\..\..\Drivers\CMSIS\Device\ST\STM32U5xx\Include;..\..\..\Drivers\BSP\Components\Common;..\..\..\Drivers\BSP\Components\hts221;..\..\..\Drivers\BSP\Components\ilps22qs;..\..\..\Drivers\BSP\Components\iis2mdc;..\..\..\Drivers\BSP\Components\ism330dhcx;..\..\..\Drivers\BSP\STWIN.box;..\..\..\Drivers\STM32U5xx_HAL_Driver\Inc;..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\..\Middlewares\ST\STM32_MotionAC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionAW_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionEC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionFX_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionGC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionID_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionMC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionPM_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionPW_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionTL_Library\Inc;..\..\..\Middlewares\Third_Party\FatFs\src\drivers;..\..\..\Middlewares\Third_Party\FatFs\src;..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC_MSC\Inc;..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x20040000 size 0x80000
software components: CMSIS:CORE 5.4.0
