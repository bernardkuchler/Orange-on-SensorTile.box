# Keil uVision project Project.uvprojx, settings and files
target STWIN.box-Project (6180000::V6.18::ARMCLANG)
  device: STM32U585AIIx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x20040000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: STWIN.box-Project.axf +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=.\STWIN.box-Project\Objects\@L.bin !L
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: STM32U585xx,USE_HAL_DRIVER,USE_USB_FS,ARM_MATH_ARMV8MML,USE_STWINBOX
  c include: ..\..\Inc;..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\CMSIS\DSP\Include;..\..\..\Drivers\CMSIS\Device\ST\STM32U5xx\Include;..\..\..\Drivers\BSP\Components\Common;..\..\..\Drivers\BSP\Components\stts22h;..\..\..\Drivers\BSP\Components\ilps22qs;..\..\..\Drivers\BSP\Components\iis2mdc;..\..\..\Drivers\BSP\Components\ism330dhcx;..\..\..\Drivers\BSP\STWIN.box;..\..\..\Drivers\STM32U5xx_HAL_Driver\Inc;..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\..\Middlewares\ST\STM32_MotionAC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionAW_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionEC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionFX_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionGC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionID_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionMC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionPM_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionPW_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionTL_Library\Inc;..\..\..\Middlewares\Third_Party\FatFs\src\drivers;..\..\..\Middlewares\Third_Party\FatFs\src;..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC_MSC\Inc;..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x20040000 size 0x80000
  group Drivers/BSP/Components
    ../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../../Drivers/BSP/Components/iis2mdc/: iis2mdc.c iis2mdc_reg.c
    ../../../Drivers/BSP/Components/ilps22qs/: ilps22qs.c ilps22qs_reg.c
    ../../../Drivers/BSP/Components/ism330dhcx/: ism330dhcx.c ism330dhcx_reg.c
    ../../../Drivers/BSP/Components/ism330is/: ism330is.c ism330is_reg.c
    ../../../Drivers/BSP/Components/stts22h/: stts22h.c stts22h_reg.c
  group Drivers/BSP/STWI.box
    ../../../Drivers/BSP/STWIN.box/: STWIN.box.c STWIN.box_bc.c STWIN.box_bus.c STWIN.box_env_sensors.c STWIN.box_env_sensors_ex.c STWIN.box_motion_sensors.c STWIN.box_motion_sensors_ex.c STWIN.box_sd.c
  group Drivers/CMSIS
    ../../Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_adc.c stm32u5xx_hal_adc_ex.c stm32u5xx_hal_cortex.c stm32u5xx_hal_crc.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_gpio.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_icache.c stm32u5xx_hal_mdf.c stm32u5xx_hal_mmc.c stm32u5xx_hal_mmc_ex.c stm32u5xx_hal_pcd.c stm32u5xx_hal_pcd_ex.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_rtc.c stm32u5xx_hal_rtc_ex.c stm32u5xx_hal_sd.c stm32u5xx_hal_sd_ex.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c stm32u5xx_ll_sdmmc.c stm32u5xx_ll_usb.c
  group Application/MDK-ARM
    ./: startup_stm32u585xx.s
  group Application/AlgoBuilder
    ../../Src/: ab_buffers.c ab_display.c ab_fft.c ab_sensor_hub.c ab_sequential_logic.c ab_signal.c ab_user_input.c
  group Application/User
    ../../Src/: algo_builder.c cube_hal_u5.c demo_serial.c fatfs.c main.c sd_diskio_STWIN.box.c sensor_commands.c serial_protocol.c stm32u5xx_hal_msp.c stm32u5xx_it.c usbd_cdc_interface.c usbd_conf.c usbd_desc.c vcom.c usbd_storage_if.c
  group Middlewares/STM32_MotionAC_Library
    ../../../Middlewares/ST/STM32_MotionAC_Library/Lib/: MotionAC_CM33F_wc16_ot.a
  group Middlewares/STM32_MotionAW_Library
    ../../../Middlewares/ST/STM32_MotionAW_Library/Lib/: MotionAW_CM33F_wc16_ot.a
  group Middlewares/STM32_MotionEC_Library
    ../../../Middlewares/ST/STM32_MotionEC_Library/Lib/: MotionEC_CM33F_wc16_ot.a
  group Middlewares/STM32_MotionFX_Library
    ../../../Middlewares/ST/STM32_MotionFX_Library/Lib/: MotionFX_CM33F_wc16_ot.a
  group Middlewares/STM32_MotionGC_Library
    ../../../Middlewares/ST/STM32_MotionGC_Library/Lib/: MotionGC_CM33F_wc16_ot.a
  group Middlewares/STM32_MotionID_Library
    ../../../Middlewares/ST/STM32_MotionID_Library/Lib/: MotionID_CM33F_wc16_ot.a
  group Middlewares/STM32_MotionMC_Library
    ../../../Middlewares/ST/STM32_MotionMC_Library/Lib/: MotionMC_CM33F_wc16_ot.a
  group Middlewares/STM32_MotionPM_Library
    ../../../Middlewares/ST/STM32_MotionPM_Library/Lib/: MotionPM_CM33F_wc16_ot.a
  group Middlewares/STM32_MotionPW_Library
    ../../../Middlewares/ST/STM32_MotionPW_Library/Lib/: MotionPW_CM33F_wc16_ot.a
  group Middlewares/STM32_MotionTL_Library
    ../../../Middlewares/ST/STM32_MotionTL_Library/Lib/: MotionTL_CM33F_wc16_ot.a
  group Middlewares/STM32_USBD_Library/Class/CDC
    ../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/CMSIS_DSP_Lib
    ../../../Drivers/CMSIS/Lib/ARM/: arm_ARMv8MMLlfsp_math.lib
  group Middlewares/FatFs/Core
    ../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Options
    ../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/STM32_USBD_Library/Class/CDC_MSC
    ../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC_MSC/Src/: usbd_cdc_msc.c
  group Middlewares/STM32_USBD_Library/Class/MSC
    ../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
target STWIN.box_ISM330IS-Project (6180000::V6.18::ARMCLANG)
  device: STM32U585AIIx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.0.0
  cpu: as above
  output: STWIN.box-Project.axf +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=.\STWIN.box_ISM330IS-Project\Objects\@L.bin !L
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: STM32U585xx,USE_HAL_DRIVER,USE_USB_FS,ARM_MATH_ARMV8MML,USE_STWINBOX, USE_ISM330IS
  c include: ..\..\Inc;..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\CMSIS\DSP\Include;..\..\..\Drivers\CMSIS\Device\ST\STM32U5xx\Include;..\..\..\Drivers\BSP\Components\Common;..\..\..\Drivers\BSP\Components\stts22h;..\..\..\Drivers\BSP\Components\ilps22qs;..\..\..\Drivers\BSP\Components\iis2mdc;..\..\..\Drivers\BSP\Components\ism330dhcx;..\..\..\Drivers\BSP\Components\ism330is;..\..\..\Drivers\BSP\STWIN.box;..\..\..\Drivers\STM32U5xx_HAL_Driver\Inc;..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\..\Middlewares\ST\STM32_MotionAC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionAW_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionEC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionFX_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionGC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionID_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionMC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionPM_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionPW_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionTL_Library\Inc;..\..\..\Middlewares\Third_Party\FatFs\src\drivers;..\..\..\Middlewares\Third_Party\FatFs\src;..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC_MSC\Inc;..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x20040000 size 0x80000
software components: CMSIS:CORE 5.4.0
