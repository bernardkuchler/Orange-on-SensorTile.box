# Keil uVision project Project_ab.uvprojx, settings and files
target STWIN-Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L4R9ZITx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IROM(0x08000000-0x81FFFFF) IROM2(0x0-0xFFFFFFFFFFFFFFFF) IROM(0x0-0xFFFFFFFFFFFFFFFF) IROM2(0x0-0xFFFFFFFFFFFFFFFF) IROM3(0x0-0xFFFFFFFFFFFFFFFF) IRAM(0x20000000-0x2002FFFF) IRAM2(0x20030000-0x2003FFFF) IRAM(0x0-0xFFFFFFFFFFFFFFFF) IRAM2(0x0-0xFFFFFFFFFFFFFFFF) IRAM3(0x0-0xFFFFFFFFFFFFFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STWIN-Project.axf +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=.\STWIN-Project\Objects\@L.bin !L
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: STM32L4R9xx,USE_HAL_DRIVER,USE_USB_FS,ARM_MATH_CM4,USE_STWIN,USE_BLE_OUTPUT
  c include: ..\..\Inc;..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\CMSIS\DSP\Include;..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\Drivers\BSP\Components\Common;..\..\..\Drivers\BSP\Components\hts221;..\..\..\Drivers\BSP\Components\lps22hh;..\..\..\Drivers\BSP\Components\iis2mdc;..\..\..\Drivers\BSP\Components\ism330dhcx;..\..\..\Drivers\BSP\STWIN;..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\..\Middlewares\ST\STM32_MotionAC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionAW_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionEC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionFX_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionGC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionID_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionMC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionPM_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionPW_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionTL_Library\Inc;..\..\..\Middlewares\Third_Party\FatFs\src\drivers;..\..\..\Middlewares\Third_Party\FatFs\src;..\..\..\Middlewares\ST\BlueNRG2\includes;..\..\..\Middlewares\ST\BlueNRG2\utils;..\..\..\Middlewares\ST\BlueNRG2\hci\hci_tl_patterns\Basic;..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC_MSC\Inc;..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x48000000 size 0x900ae806
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x20030000 size 0x10000
  group Drivers/BSP/Components
    ./STWIN-Project/Objects/: hts221.o hts221_reg.o iis2mdc.o iis2mdc_reg.o ism330dhcx.o ism330dhcx_reg.o lps22hh.o lps22hh_reg.o
  group Drivers/BSP/STWIN
    ./STWIN-Project/Objects/: stwin.o stwin_bus.o stwin_env_sensors.o stwin_env_sensors_ex.o stwin_motion_sensors.o stwin_motion_sensors_ex.o stwin_sd.o
  group Drivers/CMSIS
    ./STWIN-Project/Objects/: system_stm32l4xx.o
  group Drivers/STM32L4xx_HAL_Driver
    ./STWIN-Project/Objects/: stm32l4xx_hal.o stm32l4xx_hal_cortex.o stm32l4xx_hal_dma.o stm32l4xx_hal_gpio.o stm32l4xx_hal_i2c.o stm32l4xx_hal_i2c_ex.o stm32l4xx_hal_pcd.o stm32l4xx_hal_pcd_ex.o stm32l4xx_hal_pwr.o stm32l4xx_hal_pwr_ex.o stm32l4xx_hal_rcc.o stm32l4xx_hal_rcc_ex.o stm32l4xx_hal_rtc.o stm32l4xx_hal_rtc_ex.o stm32l4xx_hal_sd.o stm32l4xx_hal_sd_ex.o stm32l4xx_hal_spi.o stm32l4xx_hal_spi_ex.o stm32l4xx_hal_tim.o stm32l4xx_hal_tim_ex.o stm32l4xx_hal_uart.o stm32l4xx_hal_uart_ex.o stm32l4xx_hal_usart.o stm32l4xx_hal_usart_ex.o stm32l4xx_ll_sdmmc.o stm32l4xx_ll_usb.o stm32l4xx_hal_adc.o stm32l4xx_hal_adc_ex.o
  group Application/MDK-ARM
    ./: startup_stm32l4r9xx.s
  group Application/AlgoBuilder
    ./STWIN-Project/Objects/: ab_buffers.o ab_display.o ab_fft.o ab_sensor_hub.o ab_sequential_logic.o ab_signal.o ab_user_input.o ab_ble.o
  group Application/User
    ../../Src/: algo_builder.c
    ./STWIN-Project/Objects/: demo_serial.o cube_hal_l4.o main.o sd_diskio_stwin.o sensor_commands.o serial_protocol.o stm32l4xx_hal_msp.o stm32l4xx_it.o usbd_cdc_interface.o usbd_conf.o usbd_desc.o vcom.o hci_tl_interface.o sensor_service.o fatfs.o usbd_storage_if.o
  group Middlewares/STM32_MotionAC_Library
    ../../../Middlewares/ST/STM32_MotionAC_Library/Lib/: MotionAC_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionAW_Library
    ../../../Middlewares/ST/STM32_MotionAW_Library/Lib/: MotionAW_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionEC_Library
    ../../../Middlewares/ST/STM32_MotionEC_Library/Lib/: MotionEC_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionFX_Library
    ../../../Middlewares/ST/STM32_MotionFX_Library/Lib/: MotionFX_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionGC_Library
    ../../../Middlewares/ST/STM32_MotionGC_Library/Lib/: MotionGC_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionID_Library
    ../../../Middlewares/ST/STM32_MotionID_Library/Lib/: MotionID_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionMC_Library
    ../../../Middlewares/ST/STM32_MotionMC_Library/Lib/: MotionMC_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionPM_Library
    ../../../Middlewares/ST/STM32_MotionPM_Library/Lib/: MotionPM_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionPW_Library
    ../../../Middlewares/ST/STM32_MotionPW_Library/Lib/: MotionPW_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionTL_Library
    ../../../Middlewares/ST/STM32_MotionTL_Library/Lib/: MotionTL_CM4F_wc16_ot.a
  group Middlewares/STM32_USBD_Library/Class/CDC
    ./STWIN-Project/Objects/: usbd_cdc.o
  group Middlewares/STM32_USBD_Library/Core
    ./STWIN-Project/Objects/: usbd_core.o usbd_ctlreq.o usbd_ioreq.o
  group Middlewares/CMSIS_DSP_Lib
    ../../../Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group Middlewares/FatFs/Core
    ./STWIN-Project/Objects/: diskio.o ff.o ff_gen_drv.o
  group Middlewares/FatFs/Options
    ./STWIN-Project/Objects/: syscall.o unicode.o
  group Middlewares/BlueNRG2/Controller
    ./STWIN-Project/Objects/: bluenrg1_gap_aci.o bluenrg1_gatt_aci.o bluenrg1_hal_aci.o bluenrg1_l2cap_aci.o
  group Middlewares/BlueNRG2/HCI_TL
    ./STWIN-Project/Objects/: bluenrg1_events.o bluenrg1_events_cb.o bluenrg1_hci_le.o hci_tl.o
  group Middlewares/BlueNRG2/utils
    ./STWIN-Project/Objects/: ble_list.o
  group Middlewares/STM32_USBD_Library/Class/CDC_MSC
    ./STWIN-Project/Objects/: usbd_cdc_msc.o
  group Middlewares/STM32_USBD_Library/Class/MSC
    ./STWIN-Project/Objects/: usbd_msc.o usbd_msc_bot.o usbd_msc_data.o usbd_msc_scsi.o
software components: CMSIS:CORE 5.6.0
