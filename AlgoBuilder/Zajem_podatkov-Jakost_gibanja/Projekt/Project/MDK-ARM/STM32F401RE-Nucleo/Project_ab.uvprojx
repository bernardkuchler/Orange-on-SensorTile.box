# Keil uVision project Project_ab.uvprojx, settings and files
target IKS02A1_ISM330IS (6180000::V6.18::ARMCLANG)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4xx-Nucleo-Project +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=.\IKS02A1_ISM330IS\Objects\@L.bin !L
  c flags: OneElfS=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F401xE,USE_STM32F4XX_NUCLEO,USE_IKS02A1,ARM_MATH_CM4,USE_NUCLEO,USE_ISM330IS
  c include: ..\..\Inc;..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\CMSIS\DSP\Include;..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\Drivers\BSP\STM32F4xx-Nucleo;..\..\..\Drivers\BSP\IKS02A1;..\..\..\Drivers\BSP\Components\Common;..\..\..\Drivers\BSP\Components\ism330dhcx;..\..\..\Drivers\BSP\Components\ism330is;..\..\..\Drivers\BSP\Components\iis2mdc;..\..\..\Middlewares\ST\STM32_MotionAC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionAW_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionEC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionFX_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionGC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionID_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionMC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionPM_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionPW_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionTL_Library\Inc
  asm include: ..\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x17fbf
  memory RVCT10: RAM 0x20017fc0 size 0x40
  link misc: --diag_suppress=L6329
  group Drivers/BSP/Components/IKS02A1
    ./IKS02A1_ISM330IS/Objects/: iis2mdc.o iis2mdc_reg.o ism330dhcx.o ism330dhcx_reg.o ism330is.o ism330is_reg.o
  group Drivers/BSP/Components/IKS01A3
    ./IKS01A3/Objects/: hts221.o hts221_reg.o lis2dw12.o lis2dw12_reg.o lis2mdl.o lis2mdl_reg.o lps22hh.o lps22hh_reg.o lsm6dso.o lsm6dso_reg.o stts751.o stts751_reg.o
  group Drivers/BSP/Components/IKS01A3_LSM6DSO16IS
    ./IKS01A3_LSM6DSO16IS/Objects/: lsm6dso16is.o lsm6dso16is_reg.o lis2dw12.o lis2dw12_reg.o lis2mdl.o lis2mdl_reg.o lps22hh.o lps22hh_reg.o hts221.o hts221_reg.o stts751.o stts751_reg.o
  group Drivers/BSP/STM32F4xx-Nucleo/IKS02A1
    ./IKS02A1_ISM330IS/Objects/: stm32f4xx_nucleo.o
  group Drivers/BSP/STM32F4xx-Nucleo/IKS01A3
    ./IKS01A3/Objects/: stm32f4xx_nucleo.o
  group Drivers/BSP/STM32F4xx-Nucleo/IKS01A3_LSM6DSO16IS
    ./IKS01A3_LSM6DSO16IS/Objects/: stm32f4xx_nucleo.o
  group Drivers/BSP/IKS02A1
    ./IKS02A1_ISM330IS/Objects/: iks02a1_motion_sensors.o iks02a1_motion_sensors_ex.o
  group Drivers/BSP/IKS01A3
    ./IKS01A3/Objects/: iks01a3_env_sensors.o iks01a3_env_sensors_ex.o iks01a3_motion_sensors.o iks01a3_motion_sensors_ex.o
  group Drivers/BSP/IKS01A3_LSM6DSO16IS
    ./IKS01A3_LSM6DSO16IS/Objects/: iks01a3_env_sensors.o iks01a3_env_sensors_ex.o iks01a3_motion_sensors.o iks01a3_motion_sensors_ex.o
  group Drivers/CMSIS/IKS02A1
    ./IKS02A1_ISM330IS/Objects/: system_stm32f4xx.o
  group Drivers/CMSIS/IKS01A3
    ./IKS01A3/Objects/: system_stm32f4xx.o
  group Drivers/CMSIS/IKS01A3_LSM6DSO16IS
    ./IKS01A3_LSM6DSO16IS/Objects/: system_stm32f4xx.o
  group Drivers/STM32F4xx_HAL_Driver/IKS02A1
    ./IKS02A1_ISM330IS/Objects/: stm32f4xx_hal.o stm32f4xx_hal_adc.o stm32f4xx_hal_adc_ex.o stm32f4xx_hal_cortex.o stm32f4xx_hal_crc.o stm32f4xx_hal_dma.o stm32f4xx_hal_dma_ex.o stm32f4xx_hal_flash.o stm32f4xx_hal_flash_ex.o stm32f4xx_hal_gpio.o stm32f4xx_hal_i2c.o stm32f4xx_hal_i2c_ex.o stm32f4xx_hal_msp.o stm32f4xx_hal_rcc.o stm32f4xx_hal_rcc_ex.o stm32f4xx_hal_rtc.o stm32f4xx_hal_rtc_ex.o stm32f4xx_hal_spi.o stm32f4xx_hal_tim.o stm32f4xx_hal_tim_ex.o stm32f4xx_hal_uart.o
  group Drivers/STM32F4xx_HAL_Driver/IKS01A3
    ./IKS01A3/Objects/: stm32f4xx_hal.o stm32f4xx_hal_adc.o stm32f4xx_hal_adc_ex.o stm32f4xx_hal_cortex.o stm32f4xx_hal_crc.o stm32f4xx_hal_dma.o stm32f4xx_hal_dma_ex.o stm32f4xx_hal_flash.o stm32f4xx_hal_flash_ex.o stm32f4xx_hal_gpio.o stm32f4xx_hal_i2c.o stm32f4xx_hal_i2c_ex.o stm32f4xx_hal_msp.o stm32f4xx_hal_rcc.o stm32f4xx_hal_rcc_ex.o stm32f4xx_hal_rtc.o stm32f4xx_hal_rtc_ex.o stm32f4xx_hal_spi.o stm32f4xx_hal_tim.o stm32f4xx_hal_tim_ex.o stm32f4xx_hal_uart.o
  group Drivers/STM32F4xx_HAL_Driver/IKS01A3_LSM6DSO16IS
    ./IKS01A3_LSM6DSO16IS/Objects/: stm32f4xx_hal.o stm32f4xx_hal_adc.o stm32f4xx_hal_adc_ex.o stm32f4xx_hal_cortex.o stm32f4xx_hal_crc.o stm32f4xx_hal_dma.o stm32f4xx_hal_dma_ex.o stm32f4xx_hal_flash.o stm32f4xx_hal_flash_ex.o stm32f4xx_hal_gpio.o stm32f4xx_hal_i2c.o stm32f4xx_hal_i2c_ex.o stm32f4xx_hal_msp.o stm32f4xx_hal_rcc.o stm32f4xx_hal_rcc_ex.o stm32f4xx_hal_rtc.o stm32f4xx_hal_rtc_ex.o stm32f4xx_hal_spi.o stm32f4xx_hal_tim.o stm32f4xx_hal_tim_ex.o stm32f4xx_hal_uart.o
  group Example/MDK-ARM
    ./: startup_stm32f401xe.s
  group Example/AlgoBuilder/IKS02A1
    ./IKS02A1_ISM330IS/Objects/: ab_buffers.o ab_display.o ab_fft.o ab_sensor_hub.o ab_sequential_logic.o ab_signal.o ab_user_input.o
  group Example/AlgoBuilder/IKS01A3
    ./IKS01A3/Objects/: ab_buffers.o ab_display.o ab_fft.o ab_sensor_hub.o ab_sequential_logic.o ab_signal.o ab_user_input.o
  group Example/AlgoBuilder/IKS01A3_LSM6DSO16IS
    ./IKS01A3_LSM6DSO16IS/Objects/: ab_buffers.o ab_display.o ab_fft.o ab_sensor_hub.o ab_sequential_logic.o ab_signal.o ab_user_input.o
  group Example/User/IKS02A1
    ../../Src/: algo_builder.c
    ./IKS02A1_ISM330IS/Objects/: com.o cube_hal_f4.o demo_serial.o main.o nucleo_f401re_bus.o sensor_commands.o serial_protocol.o stm32f4xx_it.o
  group Example/User/IKS01A3
    ../../Src/: algo_builder.c
    ./IKS01A3/Objects/: com.o cube_hal_f4.o demo_serial.o main.o nucleo_f401re_bus.o sensor_commands.o serial_protocol.o stm32f4xx_it.o
  group Example/User/IKS01A3_LSM6DSO16IS
    ../../Src/: algo_builder.c
    ./IKS01A3_LSM6DSO16IS/Objects/: com.o cube_hal_f4.o demo_serial.o main.o nucleo_f401re_bus.o sensor_commands.o serial_protocol.o stm32f4xx_it.o
  group Middlewares/STM32_MotionAC_Library
    ../../../Middlewares/ST/STM32_MotionAC_Library/Lib/: MotionAC_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionAW_Library
    ../../../Middlewares/ST/STM32_MotionAW_Library/Lib/: MotionAW_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionEC_Library
    ../../../Middlewares/ST/STM32_MotionEC_Library/Lib/: MotionEC_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionFX_Library
    ../../../Middlewares/ST/STM32_MotionFX_Library/Lib/: MotionFX_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionGC_Library
    ../../../Middlewares/ST/STM32_MotionGC_Library/Lib/: MotionGC_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionID_Library
    ../../../Middlewares/ST/STM32_MotionID_Library/Lib/: MotionID_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionMC_Library
    ../../../Middlewares/ST/STM32_MotionMC_Library/Lib/: MotionMC_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionPM_Library
    ../../../Middlewares/ST/STM32_MotionPM_Library/Lib/: MotionPM_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionPW_Library
    ../../../Middlewares/ST/STM32_MotionPW_Library/Lib/: MotionPW_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionTL_Library
    ../../../Middlewares/ST/STM32_MotionTL_Library/Lib/: MotionTL_CM4F_wc16_ot.a
  group Middlewares/CMSIS_DSP_Lib
    ../../../Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
target IKS01A3 (6180000::V6.18::ARMCLANG)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: as above
  output: STM32F4xx-Nucleo-Project +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=.\IKS01A3\Objects\@L.bin !L
  c flags: OneElfS=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F401xE,USE_STM32F4XX_NUCLEO,USE_IKS01A3,ARM_MATH_CM4,USE_NUCLEO
  c include: ..\..\Inc;..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\CMSIS\DSP\Include;..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\Drivers\BSP\STM32F4xx-Nucleo;..\..\..\Drivers\BSP\IKS01A3;..\..\..\Drivers\BSP\Components\Common;..\..\..\Drivers\BSP\Components\hts221;..\..\..\Drivers\BSP\Components\lps22hh;..\..\..\Drivers\BSP\Components\lsm6dso;..\..\..\Drivers\BSP\Components\lis2mdl;..\..\..\Drivers\BSP\Components\lis2dw12;..\..\..\Drivers\BSP\Components\stts751;..\..\..\Middlewares\ST\STM32_MotionAC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionAW_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionEC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionFX_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionGC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionID_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionMC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionPM_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionPW_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionTL_Library\Inc
  asm include: ..\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x17fbf
  memory RVCT10: RAM 0x20017fc0 size 0x40
  link misc: --diag_suppress=L6329
target IKS01A3_LSM6DSO16IS (6180000::V6.18::ARMCLANG)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: as above
  output: STM32F4xx-Nucleo-Project +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=.\IKS01A3_LSM6DSO16IS\Objects\@L.bin !L
  c flags: OneElfS=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F401xE,USE_STM32F4XX_NUCLEO,USE_IKS01A3,USE_LSM6DSO16IS,ARM_MATH_CM4,USE_NUCLEO
  c include: ..\..\Inc;..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\CMSIS\DSP\Include;..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\Drivers\BSP\STM32F4xx-Nucleo;..\..\..\Drivers\BSP\IKS01A3;..\..\..\Drivers\BSP\Components\Common;..\..\..\Drivers\BSP\Components\hts221;..\..\..\Drivers\BSP\Components\lps22hh;..\..\..\Drivers\BSP\Components\lsm6dso;..\..\..\Drivers\BSP\Components\lis2mdl;..\..\..\Drivers\BSP\Components\lis2dw12;..\..\..\Drivers\BSP\Components\stts751;..\..\..\Drivers\BSP\Components\lsm6dso16is;..\..\..\Middlewares\ST\STM32_MotionAC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionAW_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionEC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionFX_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionGC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionID_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionMC_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionPM_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionPW_Library\Inc;..\..\..\Middlewares\ST\STM32_MotionTL_Library\Inc
  asm include: ..\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x17fbf
  memory RVCT10: RAM 0x20017fc0 size 0x40
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 5.6.0
