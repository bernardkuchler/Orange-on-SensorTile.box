# IAR project Project.ewp, settings and files
configuration STWIN.box-Project (ARM, debug)
  General.OGChipSelectEditMenu: STM32U585AI ST STM32U585AI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: CMSIS_device_header=<stm32u5xx.h>; STM32U585xx; USE_HAL_DRIVER; USE_STWINBOX; USE_USB_FS; ARM_MATH_ARMV8MML
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\Drivers\CMSIS\Include; ..\..\..\Drivers\CMSIS\DSP\Include; ..\..\..\Drivers\CMSIS\Device\ST\STM32U5xx\Include; ..\..\..\Drivers\STM32U5xx_HAL_Driver\Inc; ..\..\..\Drivers\BSP\Components\stts22h; ..\..\..\Drivers\BSP\Components\ilps22qs; ..\..\..\Drivers\BSP\Components\iis2mdc; ..\..\..\Drivers\BSP\Components\ism330dhcx; ..\..\..\Drivers\BSP\Components\Common; ..\..\..\Drivers\BSP\STWIN.box; ..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\Middlewares\ST\STM32_MotionAC_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionAW_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionEC_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionFX_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionGC_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionID_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionMC_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionPM_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionPW_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionTL_Library\Inc; ..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\Middlewares\Third_Party\FatFs\src\drivers; ..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC_MSC\Inc; ..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: STWIN.box-Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32u585xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STWIN.box_ISM330IS-Project (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CMSIS_device_header=<stm32u5xx.h>; STM32U585xx; USE_HAL_DRIVER; USE_STWINBOX; USE_ISM330IS; USE_USB_FS; ARM_MATH_ARMV8MML
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\Drivers\CMSIS\Include; ..\..\..\Drivers\CMSIS\DSP\Include; ..\..\..\Drivers\CMSIS\Device\ST\STM32U5xx\Include; ..\..\..\Drivers\STM32U5xx_HAL_Driver\Inc; ..\..\..\Drivers\BSP\Components\stts22h; ..\..\..\Drivers\BSP\Components\ilps22qs; ..\..\..\Drivers\BSP\Components\iis2mdc; ..\..\..\Drivers\BSP\Components\ism330dhcx; ..\..\..\Drivers\BSP\Components\ism330is; ..\..\..\Drivers\BSP\Components\Common; ..\..\..\Drivers\BSP\STWIN.box; ..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\Middlewares\ST\STM32_MotionAC_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionAW_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionEC_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionFX_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionGC_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionID_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionMC_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionPM_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionPW_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionTL_Library\Inc; ..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\Middlewares\Third_Party\FatFs\src\drivers; ..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC_MSC\Inc; ..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc
  group Drivers/BSP/Components
    ../../../Drivers/BSP/Components/iis2mdc/: iis2mdc.c iis2mdc_reg.c
    ../../../Drivers/BSP/Components/ilps22qs/: ilps22qs.c ilps22qs_reg.c
    ../../../Drivers/BSP/Components/ism330dhcx/: ism330dhcx.c ism330dhcx_reg.c
    ../../../Drivers/BSP/Components/ism330is/: ism330is.c ism330is_reg.c
    ../../../Drivers/BSP/Components/stts22h/: stts22h.c stts22h_reg.c
  group Drivers/BSP/STWIN.box
    ../../../Drivers/BSP/STWIN.box/: STWIN.box.c STWIN.box_bc.c STWIN.box_bus.c STWIN.box_env_sensors.c STWIN.box_env_sensors_ex.c STWIN.box_motion_sensors.c STWIN.box_motion_sensors_ex.c STWIN.box_sd.c
  group Drivers/CMSIS
    ../../Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_adc.c stm32u5xx_hal_adc_ex.c stm32u5xx_hal_cortex.c stm32u5xx_hal_crc.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_gpio.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_icache.c stm32u5xx_hal_mdf.c stm32u5xx_hal_mmc.c stm32u5xx_hal_mmc_ex.c stm32u5xx_hal_pcd.c stm32u5xx_hal_pcd_ex.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_rtc.c stm32u5xx_hal_rtc_ex.c stm32u5xx_hal_sd.c stm32u5xx_hal_sd_ex.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c stm32u5xx_ll_sdmmc.c stm32u5xx_ll_usb.c
  group Example/AlgoBuilder
    ../../Src/: ab_buffers.c ab_display.c ab_fft.c ab_sensor_hub.c ab_sequential_logic.c ab_signal.c ab_user_input.c
  group Example/EWARM
    ./: startup_stm32u585xx.s
  group Example/User
    ../../Src/: algo_builder.c cube_hal_u5.c demo_serial.c fatfs.c main.c sd_diskio_STWIN.box.c sensor_commands.c serial_protocol.c stm32u5xx_hal_msp.c stm32u5xx_it.c usbd_cdc_interface.c usbd_conf.c usbd_desc.c usbd_storage_if.c vcom.c
  group Middlewares/FatFs/Core
    ../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Options
    ../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/STM32_MotionAC_Library
    ../../../Middlewares/ST/STM32_MotionAC_Library/Lib/: MotionAC_CM33F_wc32_ot.a
  group Middlewares/STM32_MotionAW_Library
    ../../../Middlewares/ST/STM32_MotionAW_Library/Lib/: MotionAW_CM33F_wc32_ot.a
  group Middlewares/STM32_MotionEC_Library
    ../../../Middlewares/ST/STM32_MotionEC_Library/Lib/: MotionEC_CM33F_wc32_ot.a
  group Middlewares/STM32_MotionFX_Library
    ../../../Middlewares/ST/STM32_MotionFX_Library/Lib/: MotionFX_CM33F_wc32_ot.a
  group Middlewares/STM32_MotionGC_Library
    ../../../Middlewares/ST/STM32_MotionGC_Library/Lib/: MotionGC_CM33F_wc32_ot.a
  group Middlewares/STM32_MotionID_Library
    ../../../Middlewares/ST/STM32_MotionID_Library/Lib/: MotionID_CM33F_wc32_ot.a
  group Middlewares/STM32_MotionMC_Library
    ../../../Middlewares/ST/STM32_MotionMC_Library/Lib/: MotionMC_CM33F_wc32_ot.a
  group Middlewares/STM32_MotionPM_Library
    ../../../Middlewares/ST/STM32_MotionPM_Library/Lib/: MotionPM_CM33F_wc32_ot.a
  group Middlewares/STM32_MotionPW_Library
    ../../../Middlewares/ST/STM32_MotionPW_Library/Lib/: MotionPW_CM33F_wc32_ot.a
  group Middlewares/STM32_MotionTL_Library
    ../../../Middlewares/ST/STM32_MotionTL_Library/Lib/: MotionTL_CM33F_wc32_ot.a
  group Middlewares/STM32_USBD_Library/Class/CDC
    ../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/STM32_USBD_Library/Class/CDC_MSC
    ../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC_MSC/Src/: usbd_cdc_msc.c
  group Middlewares/STM32_USBD_Library/Class/MSC
    ../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
