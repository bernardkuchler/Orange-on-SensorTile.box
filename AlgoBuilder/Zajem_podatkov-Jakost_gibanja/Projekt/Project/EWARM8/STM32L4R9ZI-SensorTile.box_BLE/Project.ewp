# IAR project Project.ewp, settings and files
configuration SensorTile.box-Project (ARM, debug)
  General.OGChipSelectEditMenu: STM32L4R9ZI ST STM32L4R9ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L4R9xx; USE_HAL_DRIVER; USE_USB_FS; USE_SENSORTILEBOX; ARM_MATH_CM4; USE_BLE_OUTPUT
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\Drivers\CMSIS\Include; ..\..\..\Drivers\CMSIS\DSP\Include; ..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\Drivers\BSP\Components\Common; ..\..\..\Drivers\BSP\Components\hts221; ..\..\..\Drivers\BSP\Components\lps22hh; ..\..\..\Drivers\BSP\Components\lis2mdl; ..\..\..\Drivers\BSP\Components\lsm6dsox; ..\..\..\Drivers\BSP\SensorTile.box; ..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\Middlewares\ST\STM32_MotionAC_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionAW_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionEC_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionFX_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionGC_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionID_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionMC_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionPM_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionPW_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionTL_Library\Inc; ..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\Middlewares\Third_Party\FatFs\src\drivers; ..\..\..\Middlewares\ST\BlueNRG2\includes; ..\..\..\Middlewares\ST\BlueNRG2\hci\hci_tl_patterns\Basic; ..\..\..\Middlewares\ST\BlueNRG2\utils; ..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC_MSC\Inc; ..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: SensorTile.box-Project.bin
  ILINK.IlinkOutputFile: SensorTile.box-Project.out
  ILINK.IlinkIcfFile: stm32l4R9xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/BSP/Components
    ../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../../Drivers/BSP/Components/lis2mdl/: lis2mdl.c lis2mdl_reg.c
    ../../../Drivers/BSP/Components/lps22hh/: lps22hh.c lps22hh_reg.c
    ../../../Drivers/BSP/Components/lsm6dsox/: lsm6dsox.c lsm6dsox_reg.c
  group Drivers/BSP/SensorTile.box
    ../../../Drivers/BSP/SensorTile.box/: SensorTile.box.c SensorTile.box_bc.c SensorTile.box_bus.c SensorTile.box_env_sensors.c SensorTile.box_env_sensors_ex.c SensorTile.box_motion_sensors.c SensorTile.box_motion_sensors_ex.c SensorTile.box_sd.c
  group Drivers/CMSIS
    ../../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_ll_sdmmc.c stm32l4xx_ll_usb.c
  group Example/AlgoBuilder
    ../../Src/: ab_ble.c ab_buffers.c ab_display.c ab_fft.c ab_sensor_hub.c ab_sequential_logic.c ab_signal.c ab_user_input.c
  group Example/EWARM
    ./: startup_stm32l4r9xx.s
  group Example/User
    ../../Src/: algo_builder.c cube_hal_l4.c demo_serial.c fatfs.c hci_tl_interface.c main.c sd_diskio_SensorTile.box.c sensor_commands.c sensor_service.c serial_protocol.c stm32l4xx_hal_msp.c stm32l4xx_it.c usbd_cdc_interface.c usbd_conf.c usbd_desc.c usbd_storage_if.c vcom.c
  group Middlewares/BlueNRG2/Controller
    ../../../Middlewares/ST/BlueNRG2/hci/controller/: bluenrg1_gap_aci.c bluenrg1_gatt_aci.c bluenrg1_hal_aci.c bluenrg1_l2cap_aci.c
  group Middlewares/BlueNRG2/HCI_TL/Basic
    ../../../Middlewares/ST/BlueNRG2/hci/: bluenrg1_events.c bluenrg1_events_cb.c bluenrg1_hci_le.c
    ../../../Middlewares/ST/BlueNRG2/hci/hci_tl_patterns/Basic/: hci_tl.c
  group Middlewares/BlueNRG2/Utils
    ../../../Middlewares/ST/BlueNRG2/utils/: ble_list.c
  group Middlewares/FatFs/Core
    ../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Options
    ../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/STM32_MotionAC_Library
    ../../../Middlewares/ST/STM32_MotionAC_Library/Lib/: MotionAC_CM4F_wc32_ot.a
  group Middlewares/STM32_MotionAW_Library
    ../../../Middlewares/ST/STM32_MotionAW_Library/Lib/: MotionAW_CM4F_wc32_ot.a
  group Middlewares/STM32_MotionEC_Library
    ../../../Middlewares/ST/STM32_MotionEC_Library/Lib/: MotionEC_CM4F_wc32_ot.a
  group Middlewares/STM32_MotionFX_Library
    ../../../Middlewares/ST/STM32_MotionFX_Library/Lib/: MotionFX_CM4F_wc32_ot.a
  group Middlewares/STM32_MotionGC_Library
    ../../../Middlewares/ST/STM32_MotionGC_Library/Lib/: MotionGC_CM4F_wc32_ot.a
  group Middlewares/STM32_MotionID_Library
    ../../../Middlewares/ST/STM32_MotionID_Library/Lib/: MotionID_CM4F_wc32_ot.a
  group Middlewares/STM32_MotionMC_Library
    ../../../Middlewares/ST/STM32_MotionMC_Library/Lib/: MotionMC_CM4F_wc32_ot.a
  group Middlewares/STM32_MotionPM_Library
    ../../../Middlewares/ST/STM32_MotionPM_Library/Lib/: MotionPM_CM4F_wc32_ot.a
  group Middlewares/STM32_MotionPW_Library
    ../../../Middlewares/ST/STM32_MotionPW_Library/Lib/: MotionPW_CM4F_wc32_ot.a
  group Middlewares/STM32_MotionTL_Library
    ../../../Middlewares/ST/STM32_MotionTL_Library/Lib/: MotionTL_CM4F_wc32_ot.a
  group Middlewares/STM32_USBD_Library/Class/CDC
    ../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/STM32_USBD_Library/Class/CDC_MSC
    ../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC_MSC/Src/: usbd_cdc_msc.c
  group Middlewares/STM32_USBD_Library/Class/MSC
    ../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
