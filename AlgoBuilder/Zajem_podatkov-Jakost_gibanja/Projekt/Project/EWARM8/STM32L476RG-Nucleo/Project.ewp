# IAR project Project.ewp, settings and files
configuration IKS01A3 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L476xx; USE_HAL_DRIVER; USE_STM32L4XX_NUCLEO; USE_IKS01A3; ARM_MATH_CM4; USE_NUCLEO
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\Drivers\CMSIS\Include; ..\..\..\Drivers\CMSIS\DSP\Include; ..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\Drivers\BSP\STM32L4xx_Nucleo; ..\..\..\Drivers\BSP\Components\Common; ..\..\..\Drivers\BSP\Components\hts221; ..\..\..\Drivers\BSP\Components\lis2mdl; ..\..\..\Drivers\BSP\Components\lps22hh; ..\..\..\Drivers\BSP\Components\lsm6dso; ..\..\..\Drivers\BSP\Components\lis2dw12; ..\..\..\Drivers\BSP\Components\stts751; ..\..\..\Drivers\BSP\IKS01A3; ..\..\..\Middlewares\ST\STM32_MotionAC_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionAW_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionEC_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionFX_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionGC_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionID_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionMC_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionPM_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionPW_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionTL_Library\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32L4xx-Nucleo-Project.bin
  ILINK.IlinkOutputFile: STM32L4xx-Nucleo-Project.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration IKS02A1_ISM330IS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32L476xx; USE_HAL_DRIVER; USE_STM32L4XX_NUCLEO; USE_IKS02A1; ARM_MATH_CM4; USE_NUCLEO; USE_ISM330IS
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\Drivers\CMSIS\Include; ..\..\..\Drivers\CMSIS\DSP\Include; ..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\Drivers\BSP\STM32L4xx_Nucleo; ..\..\..\Drivers\BSP\Components\Common; ..\..\..\Drivers\BSP\Components\iis2mdc; ..\..\..\Drivers\BSP\Components\ism330dhcx; ..\..\..\Drivers\BSP\Components\ism330is; ..\..\..\Drivers\BSP\IKS02A1; ..\..\..\Middlewares\ST\STM32_MotionAC_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionAW_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionEC_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionFX_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionGC_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionID_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionMC_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionPM_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionPW_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionTL_Library\Inc
configuration IKS01A3_LSM6DSO16IS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32L476xx; USE_HAL_DRIVER; USE_STM32L4XX_NUCLEO; USE_IKS01A3; USE_LSM6DSO16IS; ARM_MATH_CM4; USE_NUCLEO
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\Drivers\CMSIS\Include; ..\..\..\Drivers\CMSIS\DSP\Include; ..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\Drivers\BSP\STM32L4xx_Nucleo; ..\..\..\Drivers\BSP\Components\Common; ..\..\..\Drivers\BSP\Components\hts221; ..\..\..\Drivers\BSP\Components\lis2mdl; ..\..\..\Drivers\BSP\Components\lps22hh; ..\..\..\Drivers\BSP\Components\lsm6dso; ..\..\..\Drivers\BSP\Components\lis2dw12; ..\..\..\Drivers\BSP\Components\stts751; ..\..\..\Drivers\BSP\Components\lsm6dso16is; ..\..\..\Drivers\BSP\IKS01A3; ..\..\..\Middlewares\ST\STM32_MotionAC_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionAW_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionEC_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionFX_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionGC_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionID_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionMC_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionPM_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionPW_Library\Inc; ..\..\..\Middlewares\ST\STM32_MotionTL_Library\Inc
  group Drivers/BSP/Components
    ../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../../Drivers/BSP/Components/iis2mdc/: iis2mdc.c iis2mdc_reg.c
    ../../../Drivers/BSP/Components/ism330dhcx/: ism330dhcx.c ism330dhcx_reg.c
    ../../../Drivers/BSP/Components/ism330is/: ism330is.c ism330is_reg.c
    ../../../Drivers/BSP/Components/lis2dw12/: lis2dw12.c lis2dw12_reg.c
    ../../../Drivers/BSP/Components/lis2mdl/: lis2mdl.c lis2mdl_reg.c
    ../../../Drivers/BSP/Components/lps22hh/: lps22hh.c lps22hh_reg.c
    ../../../Drivers/BSP/Components/lsm6dso/: lsm6dso.c lsm6dso_reg.c
    ../../../Drivers/BSP/Components/lsm6dso16is/: lsm6dso16is.c lsm6dso16is_reg.c
    ../../../Drivers/BSP/Components/stts751/: stts751.c stts751_reg.c
  group Drivers/BSP/IKS01A3
    ../../../Drivers/BSP/IKS01A3/: iks01a3_env_sensors.c iks01a3_env_sensors_ex.c iks01a3_motion_sensors.c iks01a3_motion_sensors_ex.c
  group Drivers/BSP/IKS02A1
    ../../../Drivers/BSP/IKS02A1/: iks02a1_motion_sensors.c iks02a1_motion_sensors_ex.c
  group Drivers/BSP/STM32L4xx_Nucleo
    ../../../Drivers/BSP/STM32L4xx_Nucleo/: stm32l4xx_nucleo.c
  group Drivers/CMSIS
    ../../../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Example/AlgoBuilder
    ../../Src/: ab_buffers.c ab_display.c ab_fft.c ab_sensor_hub.c ab_sequential_logic.c ab_signal.c ab_user_input.c
  group Example/EWARM
    ./: startup_stm32l476xx.s
  group Example/User
    ../../Src/: algo_builder.c com.c cube_hal_l4.c demo_serial.c main.c nucleo_l476rg_bus.c sensor_commands.c serial_protocol.c stm32l4xx_hal_msp.c stm32l4xx_it.c
  group Middlewares/STM32_MotionAC_Library
    ../../../Middlewares/ST/STM32_MotionAC_Library/Lib/: MotionAC_CM4F_wc32_ot.a
  group Middlewares/STM32_MotionAW_Library
    ../../../Middlewares/ST/STM32_MotionAW_Library/Lib/: MotionAW_CM4F_wc32_ot.a
  group Middlewares/STM32_MotionEC_Library
    ../../../Middlewares/ST/STM32_MotionEC_Library/Lib/: MotionEC_CM4F_wc32_ot.a
  group Middlewares/STM32_MotionFX_Library
    ../../../Middlewares/ST/STM32_MotionFX_Library/Lib/: MotionFX_CM4F_wc32_ot.a
  group Middlewares/STM32_MotionGC_Library
    ../../../Middlewares/ST/STM32_MotionGC_Library/Lib/: MotionGC_CM4F_wc32_ot.a
  group Middlewares/STM32_MotionID_Library
    ../../../Middlewares/ST/STM32_MotionID_Library/Lib/: MotionID_CM4F_wc32_ot.a
  group Middlewares/STM32_MotionMC_Library
    ../../../Middlewares/ST/STM32_MotionMC_Library/Lib/: MotionMC_CM4F_wc32_ot.a
  group Middlewares/STM32_MotionPM_Library
    ../../../Middlewares/ST/STM32_MotionPM_Library/Lib/: MotionPM_CM4F_wc32_ot.a
  group Middlewares/STM32_MotionPW_Library
    ../../../Middlewares/ST/STM32_MotionPW_Library/Lib/: MotionPW_CM4F_wc32_ot.a
  group Middlewares/STM32_MotionTL_Library
    ../../../Middlewares/ST/STM32_MotionTL_Library/Lib/: MotionTL_CM4F_wc32_ot.a
